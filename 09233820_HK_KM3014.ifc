Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: 8c543124-5657-4d99-9242-28da21330402, NumberOfSaves: 1]
File name: 0001
Time: 2026-09-10T21:40:29+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 09233820_HK_KM3014:26301450_HK_9233820_KM3014, (2)
In: Default
Type - Material: z_Miele_Design_Steel_Chrom, z_Miele_Design_CLST, z_Miele_Design_Zinc_Steel, z_Miele_Design_Cast_Grey, <Unnamed>, z_Miele_Design_Glass Black, z_Miele_Connection_Gas, z_Miele_Connection_Electric
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_ProvisionForVoid - Width: 626 mm; Height: 53 mm; Depth: 526 mm
Pset_BuildingElementProxyCommon - Reference: 26301450_HK_9233820_KM3014; sets with these values: 2

# IfcDistributionPort, Port_363867_1
Description: Flow; FlowDirection: SOURCEANDSINK
